FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://interactive.cfg"
